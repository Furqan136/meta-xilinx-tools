SRC_URI = "http://easource.alm.mentorg.com/sources/elm/embeddedsw.tar.gz"

EMBEDDEDSW_PV="2018.3+git+${EMBEDDEDSW_SRCREV}"

SRC_URI[md5sum] = "09da46a20b2ff17e26c0c4da2ea09ba8"
SRC_URI[sha256sum] = "957bb176a1e0dcd1d42c4bfdc6a174d0241408769edd4001b62a1885929a184c"
